Properties of the parts of a building model (IFC4)

# File
Description: Skyline Kontrast Sib. Lärche gehobelt 28 x 69 5.05m, File generated by Heinze, ViewDefinition[CoordinationView]
File name: file.ifc
Time: 2025-01-31T12:28:24+0100
Author: Heinze GmbH, kundenservice@heinze.de
Organization: Heinze GmbH, Bremer Weg 184, 29223 Celle, Tel. +49 (0)5141 5055, https://www.heinze.de/
Written by: N/A
Made in: Heinze
Authorization: N/A

# IfcProject, Ladenburger Project
Description: Ladenburger GmbH default project for Heinze

# IfcBuilding, Ladenburger Building
Description: Ladenburger GmbH default building for Heinze

# IfcBuildingStorey, Default Storey
In: Ladenburger Building
Description: Default storey

# IfcSpace, Default Space
In: Default Storey
Description: Default space for placing elements

# IfcBuildingElementProxy, Skyline Kontrast Sib. Lärche gehobelt 28 x 69 5.05m
In: Default Space
Description: Das besondere Plus an Kreativität. SKYLINE Kontrast verleiht jedem Gebäude einen individuellen, einzigartigen Charakter: Keine Fassade gleicht der anderen. Auch das Erscheinungsbild jeder einzelnen Fassade wirkt je nach Betrachtungswinkel unterschiedlich.
Pset_BIMSITE - Farbton: beige, braun, farblos, grau, metallfarben, nach Hersteller-Farbkarte, orange; Oberfläche: gehobelt, unbehandelt; Werkstoff: Holz; Breite: 69; Länge: 5050; Stärke: 28; Art: Steckaußenschalung mit Nut und Feder; Holzart: Lärche, Sibirische Lärche; Holzsortierung: A-Sortierung, B-Sortierung
Pset_BIMsite_ProductCodes - Description: PropertySet with ProductCodes
Pset_BIMsite_Documents - DOCUMENT_USAGE_TYPE_DATASHEET 1: https://media.heinze.de/m2/88/62488/etc/83/47482783.pdf; DOCUMENT_USAGE_TYPE_DATASHEET 2: https://media.heinze.de/m2/88/62488/etc/79/47482779.pdf; DOCUMENT_USAGE_TYPE_VIDEO 3: https://youtu.be/GIHxCpN8_Jc
Pset_BIMsite_Links - LINK_TYPE_TOOL 1: https://ladenburger.de/konfigurator/; LINK_TYPE_PRODUCT_PAGE 2: https://www.ladenburger.de/index.php/de/fassaden-profilholz/kontrast-edition/skyline-kontrast
Pset_BIMsite_Categories - HEINZE_CATEGORY: Profilholz-Bretter
Pset_BIMsite_ManufacturerProperties - Deckmaß (mm): 49; Eigenschaften: durch das Nut und Feder Fassadenprofil kann auf UV-beständige Unterspannbahnen verzichtet werden, leistet Beitrag zur Dämmwirkung der Gebäudehülle; Farbton 1: UV-Plus, Sanddorn, Antikgrau, Kieselgrau, Naturgrau, Schiefergrau, Mokka, Altgrau (Metallic-Effekt); Oberflächenausbildung: 8 mögliche Farbtöne; Sichtkanten gebrochen: Ja; Stk. pro Bund: 4; Stk. pro Paket: 192
